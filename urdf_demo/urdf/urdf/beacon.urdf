Commit message: feat：学习关于 urdf 相关内容

File: urdf_demo/urdf/urdf/beacon.urdf (robot description, URDF)
Before this commit: robot beacon, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://urdf_demo/meshes/bases/burger_base.stl scale=0.001 0.001 0.001
